# Keil uVision project freertos_lowpower.uvprojx, settings and files
target freertos_lowpower (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: freertos_lowpower
  AfterMake: fromelf --bin --output bin\freertos_lowpower.bin bin\freertos_lowpower.axf
  AfterMake: fromelf -cedrst --output bin\freertos_lowpower.txt bin\freertos_lowpower.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO3 AM_UTIL_FAULTISR_PRINT AM_DEBUG_PRINTF AM_FREERTOS AM_PACKAGE_BGA keil6
  c include: ../../../../..;../../../bsp;../../../../../CMSIS/ARM/Include;../../../../../utils;../../../../../third_party/FreeRTOSv10.5.1/Source/include;../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo2;../../../../../CMSIS/AmbiqMicro/Include;../../../../../mcu/apollo3;../../../../../devices;../src
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\freertos_lowpower.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group FreeRTOSv10.5.1_AMapollo2
    ../../../../../third_party/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo2/: port.c
  group src
    ../src/: freertos_lowpower.c led_task.c rtos.c
  group devices
    ../../../../../devices/: am_devices_button.c am_devices_led.c
  group FreeRTOSv10.5.1_MemMang
    ../../../../../third_party/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_2.c
  group utils
    ../../../../../utils/: am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group FreeRTOSv10.5.1_Source
    ../../../../../third_party/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
