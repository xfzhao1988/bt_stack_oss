# Keil uVision project pwr_iom_spi.uvprojx, settings and files
target pwr_iom_spi (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: pwr_iom_spi
  AfterMake: fromelf --bin --output bin\pwr_iom_spi.bin bin\pwr_iom_spi.axf
  AfterMake: fromelf -cedrst --output bin\pwr_iom_spi.txt bin\pwr_iom_spi.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3 keil6
  c include: ../src;../../../bsp;../../../../../CMSIS/ARM/Include;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../mcu/apollo3;../../../../../utils;../../../../../devices
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\pwr_iom_spi.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: pwr_control_utils.c pwr_gpio_utils.c pwr_iom_spi.c pwr_iom_utils.c timer_utils.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
