# Keil uVision project uart_async.uvprojx, settings and files
target uart_async (ARM-ADS)
  device: AMA3B1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.1.0
  cpu: IRAM(0x10000000,0x00060000) IROM(0x0000C000,0x000F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: uart_async
  AfterMake: fromelf --bin --output bin\uart_async.bin bin\uart_async.axf
  AfterMake: fromelf -cedrst --output bin\uart_async.txt bin\uart_async.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PART_APOLLO3 AM_PACKAGE_BGA keil6
  c include: ../../../../../mcu/apollo3;../../../../../CMSIS/AmbiqMicro/Include;../../../../..;../../../../../CMSIS/ARM/Include;../../../../../utils;../../../bsp;../src;../../../../../devices
  memory RVCT4: ROM 0xC000 size 0xF4000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\uart_async.sct
  link misc: ../../../../../mcu/apollo3/hal/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: timer_utils.c uart_async.c uart_async_utils.c
  group utils
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
