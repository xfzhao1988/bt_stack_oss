# Keil uVision project deepsleep.uvprojx, settings and files
target deepsleep (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: deepsleep
  AfterMake: fromelf --bin --output bin\deepsleep.bin bin\deepsleep.axf
  AfterMake: fromelf -cedrst --output bin\deepsleep.txt bin\deepsleep.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PRINTF_BUFSIZE=256 AM_PACKAGE_BGA AM_PART_APOLLO3P keil6
  c include: ../src;../../../../../utils;../../../../../CMSIS/ARM/Include;../../../../../devices;../../../bsp;../../../../../mcu/apollo3p;../../../../..;../../../../../CMSIS/AmbiqMicro/Include
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: deepsleep.c
  group utils
    ../../../../../utils/: am_util_ble.c am_util_delay.c am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
