# Keil uVision project while.uvprojx, settings and files
target while (ARM-ADS)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: while
  AfterMake: fromelf --bin --output bin\while.bin bin\while.axf
  AfterMake: fromelf -cedrst --output bin\while.txt bin\while.axf
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO3P AM_PRINTF_BUFSIZE=256 keil6
  c include: ../../../../../utils;../../../../../mcu/apollo3p;../../../../../CMSIS/ARM/Include;../../../../../CMSIS/AmbiqMicro/Include;../../../bsp;../src;../../../../../devices;../../../../..
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  scatter file: .\linker_script.sct
  link misc: ../../../../../mcu/apollo3p/hal/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: while.c
  group utils
    ../../../../../utils/: am_util_stdio.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../mcu/apollo3p/hal/keil6/bin/: libam_hal.lib
