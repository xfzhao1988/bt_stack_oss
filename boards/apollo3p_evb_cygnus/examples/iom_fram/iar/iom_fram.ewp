# IAR project iom_fram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO3P
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\mcu\apollo3p; ..\src; ..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\bsp; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\utils; ..\..\..\..\..; ..\..\..\..\..\devices
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: iom_fram.bin
  ILINK.IlinkOutputFile: iom_fram.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO3P
  group (top)
    ../src/: iom_fram.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_mb85rc256v.c
    ./: startup_iar.c
