# IAR project mspi_flash_loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMA3B2KK-KBR AmbiqMicro AMA3B2KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO3P; ADESTO_ATXP032; AM_PACKAGE_BGA
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo3p; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..; ..\..\..\..\..\CMSIS\ARM\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mspi_flash_loader.bin
  ILINK.IlinkOutputFile: mspi_flash_loader.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo3p\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; iar; AM_UTIL_FAULTISR_PRINT; AM_PART_APOLLO3P; ADESTO_ATXP032; AM_PACKAGE_BGA
  group (top)
    ../src/: mspi_flash_loader.c
    ../../../../../devices/: am_devices_mspi_atxp032.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ./: startup_iar.c
